options:
  parameters:
    author: pranav
    generate_options: qt_gui
    id: task3
    output_language: python
    title: Equalizer
  states: {}

blocks:
- name: band1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: band2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: band3
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: band4
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: band5
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: band1
    high_cutoff_freq: '500'
    interp: '1'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '10'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: band2
    high_cutoff_freq: '3000'
    interp: '1'
    low_cutoff_freq: '500'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '10'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    gain: band3
    high_cutoff_freq: '6000'
    interp: '1'
    low_cutoff_freq: '3000'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '10'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    gain: band4
    high_cutoff_freq: '9000'
    interp: '1'
    low_cutoff_freq: '6000'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '10'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_0_0_0_0
  id: band_pass_filter
  parameters:
    gain: band5
    high_cutoff_freq: '15000'
    interp: '1'
    low_cutoff_freq: '9000'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '10'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /media/pranav/page/Laptop data/Coursework/Semester 9/EE340/Inputs/Bach.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_0_0, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0_0_0, '0', blocks_add_xx_0, '2']
- [band_pass_filter_0_0_0_0, '0', blocks_add_xx_0, '3']
- [band_pass_filter_0_0_0_0_0, '0', blocks_add_xx_0, '4']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_0_0_0_0, '0']

metadata:
  file_format: 1
